# Keil uVision project ThreeDPrint_DA1.uvprojx, settings and files
target ThreeDPrint_DA1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F429BITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: ThreeDPrint_DA1 +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FatFs/src/drivers;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Middlewares/Third_Party/FatFs/src;../Drivers/CMSIS/Include;..\Printer\Applies;..\Printer\Definition;..\Printer\Drivers;..\Printer\Lib;..\Printer\Modules;..\Printer\Modules\PositionMng;..\Ethernet
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Middlewares/USB_Host_Library
    ../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_ctlreq.c usbh_core.c usbh_ioreq.c usbh_pipes.c
    ../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group Application/User
    ../Src/: tim.c gpio.c usbd_conf.c main.c usbd_cdc_if.c usart.c dma.c adc.c sdio.c bsp_driver_sd.c usb_host.c fatfs.c usb_device.c usbh_conf.c iwdg.c stm32f4xx_hal_msp.c stm32f4xx_it.c usbd_desc.c spi.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ioreq.c usbd_core.c usbd_ctlreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pwr.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_hcd.c stm32f4xx_hal.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_rcc.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_tim.c stm32f4xx_hal_adc.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_spi.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c cc936.c
    ../Middlewares/Third_Party/FatFs/src/: ff.c ff_gen_drv.c diskio.c
    ../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Printer/Drivers
    ../Printer/Drivers/: AxisCtrl.c FanCtrl.c HeatCtrl.c Input.c TempSensor.c BrakeCtrl.c LampCtrl.c RS485.c
  group Printer/Lib
    ../Printer/Lib/: Calculate.c Queue.c
  group Printer/Definition
    ../Printer/Definition/: Globals.c
  group Printer/Modules
    ../Printer/Modules/: DataParse.c ErrorMng.c EventMng.c PrintDataMng.c ProtocolData.c ProtocolMng.c TaskMng.c TempCtrl.c WifiMng.c
    ../Printer/Modules/PositionMng/: Homing.c planner.c PositionMng.c stepper.c
  group Printer/Applies
    ../Printer/Applies/: PortalFrame.c Print.c PrinterCtrl.c
  group Ethernet
    ../Ethernet/: loopback.c socket.c w5500.c wizchip_conf.c network.c dhcp.c
software components: CMSIS:CORE 4.1.0
